SUMMARY = "Barcode scanning SDK for Python"
DESCRIPTION = "The Python Barcode SDK is a wrapper for Dynamsoft C++ Barcode SDK. \
It comes with all the general features of Dynamsoft Barcode Reader, bringing \
convenience for Python developers."

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SRC_URI[sha256sum] = "e671a53522515f34fd406340ee968cb9ecafbc4b36c679da03c18fd8d0bd51ac"

inherit pypi setuptools3

