SUMMARY = "Python Core Audio Windows Library"
DESCRIPTION = "Python Core Audio Windows Library, working for both Python2 and Python3."

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SRC_URI[sha256sum] = "55e49359e9f227053f4fa15817a02d4a7bc52fc3db32e123894719a123c41d06"

inherit pypi setuptools3

